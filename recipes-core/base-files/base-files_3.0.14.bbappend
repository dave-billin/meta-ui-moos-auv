# U of I MOOS-AUV Bash Profile

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
